# Keil uVision project MOTION_CARD.uvprojx, settings and files
target MotionCard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOTION_CARD
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\User;.\xp;.\CMSIS;.\STM32F4xx_StdPeriph_Driver\sys;.\MotionCard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c can.c gpio.c stm32f4xx_it.c timer.c usart.c
  group Startup
    ./CMSIS/startup/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c
  group xp
    ./xp/: debug.c threeWheelMove.c action_driver.c update.c motionCard.lib flash.c
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
